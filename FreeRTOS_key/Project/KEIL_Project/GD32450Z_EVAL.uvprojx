# Keil uVision project GD32450Z_EVAL.uvprojx, settings and files
target GD32450Z_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F407RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32407RE_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c include: ..\..\Project;..\..\..\Library\Firmware\GD32F4xx_standard_peripheral\Include;..\..\..\Library\Utilities;..\..\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\include;..\..\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\Library\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\..\Library\Firmware\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: gd32f4xx_it.c main.c kcm_driver.c gd32fr_uwb.c gd32fr_um4b0.c gd32fr_wifi.c
  group GD32F4xx_Peripherals
    ../../../Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group FreeRTOS
    ../../Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group CMSIS
    ../../../Library/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_EVAL
    ../../../Library/Utilities/: gd32f450z_eval.c
  group Startup
    ../../../Library/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
software components: CMSIS:CORE 5.2.0
