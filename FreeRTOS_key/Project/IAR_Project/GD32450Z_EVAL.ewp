# IAR project GD32450Z_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xK GD GD32F450xK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F450
  ICCARM.CCIncludePath2: ..; ..\..\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\include; ..\..\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\Library\Utilities; ..\..\..\Library\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\..\Library\Firmware\CMSIS; ..\..\..\Library\Firmware\GD32F4xx_standard_peripheral\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\Library\Firmware\CMSIS
  OBJCOPY.OOCOutputFile: GD32450Z_EVAL.srec
  ILINK.IlinkOutputFile: GD32307C_EVAL.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32f4xx_it.c main.c
  group CMSIS
    ../../../Library/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group FreeRTOS
    ../../Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group GD32F4xx_EVAL
    ../../../Library/Utilities/: gd32f450z_eval.c
  group GD32F4xx_Peripherals
    ../../../Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../../../Library/Firmware/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450.s
